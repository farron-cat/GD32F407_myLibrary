# Keil uVision project GD32F407_myLibrary.uvprojx, settings and files
target GD32F407 (6240000::V6.24::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: My_GD32F407_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,HXTAL_VALUE=8000000,SYS_SUPPORT_OS
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Driver\bsp_leds;..\Driver\bsp_keys;..\App;..\Middleware;..\Hardware\msp_exti;..\Driver\bsp_188_leds;..\Driver\bsp_adkey;..\Driver\bsp_battery_flows;..\Driver\bsp_buzzer;..\Driver\bsp_digital_leds;..\Driver\bsp_dot_matrix;..\Driver\bsp_ec12d;..\Driver\bsp_flash;..\Driver\bsp_iic_oled;..\Driver\bsp_keypad;..\Driver\bsp_ntc;..\Driver\bsp_pcf8563;..\Driver\bsp_spi_oled;..\Driver\bsp_touch_key;..\Hardware\msp_adc;..\Hardware\msp_fwdgt;..\Hardware\msp_iic;..\Hardware\msp_rtc;..\Hardware\msp_spi;..\Hardware\msp_uart;..\Hardware\msp_wwdgt;..\Middleware\FreeRTOS\include;..\Middleware\FreeRTOS\portable\GCC\ARM_CM4F;..\Middleware\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group App
    ../App/app_input/: app_input.c
    ../App/app_show/: app_show.c
    ../App/app_test/: app_test.c
  group Middleware
    ../Middleware/: taskmanager.c
  group Driver
    ../Driver/bsp_leds/: bsp_leds.c
    ../Driver/bsp_keys/: bsp_keys.c
    ../Driver/bsp_iic_oled/: bmp.c bsp_iic_oled.c
    ../Driver/bsp_188_leds/: bsp_188_leds.c
    ../Driver/bsp_adkey/: bsp_adkey.c
    ../Driver/bsp_touch_key/: bsp_touch_key.c
    ../Driver/bsp_keypad/: bsp_keypad.c
    ../Driver/bsp_ntc/: bsp_ntc.c
    ../Driver/bsp_pcf8563/: bsp_pcf8563.c
    ../Driver/bsp_digital_leds/: bsp_digital_leds.c
    ../Driver/bsp_dot_matrix/: bsp_dot_matrix.c
    ../Driver/bsp_flash/: bsp_flash.c
    ../Driver/bsp_spi_oled/: bsp_spi_oled.c
    ../Driver/bsp_buzzer/: bsp_buzzer.c
    ../Driver/bsp_ec12d/: bsp_ec12d.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_dma.c gd32f4xx_adc.c gd32f4xx_exti.c gd32f4xx_pmu.c gd32f4xx_rtc.c gd32f4xx_syscfg.c gd32f4xx_usart.c gd32f4xx_timer.c gd32f4xx_spi.c gd32f4xx_i2c.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Hardware
    ../Hardware/msp_adc/: msp_adc.c
    ../Hardware/msp_exti/: msp_exti.c
    ../Hardware/msp_iic/: msp_iic.c
    ../Hardware/msp_rtc/: msp_rtc.c
    ../Hardware/msp_spi/: msp_spi.c
    ../Hardware/msp_uart/: msp_uart.c
  group FreeRTOS_core
    ../Middleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_port
    ../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middleware/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
